<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00046.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="FE665A72-D106-4EB6-A9D5-AA38FF2F0419">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="07F31E08-9F29-4170-8020-E71D84663126">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="201176C6-11A3-4C5C-A962-BF8E809C43FB">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="4F9E3650-D051-45C2-8048-A964F16EA33A">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="02CEE673-DB27-472D-B767-9E2385A16DC3">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7AF57DB7-495E-4B10-AF54-C07336FD26BB">
      <SHORT-NAME>VehicleProject</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A8AA0B1C-A39E-4616-A914-14EC9223E016">
      <SHORT-NAME>NM</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E85950BC-E71A-4E8D-8DB2-F43DA6FE0928">
      <SHORT-NAME>TP</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="AE4F55EE-424E-4754-910F-F117F86D7482">
      <SHORT-NAME>Cluster</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B962072A-E9D4-4544-AC00-22A8C4581886">
      <SHORT-NAME>ECU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="FB66157D-281A-40C8-9C05-769F7471451F">
      <SHORT-NAME>IPDUGroup</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3BD1F4A4-1AD9-4D5D-B6E4-5F22A07FAB43">
      <SHORT-NAME>CanFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="BFAD8DCD-F6A0-46A3-BF17-271D8EC50654">
      <SHORT-NAME>PDU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D329064C-BEDE-4134-BD7B-153906269D74">
      <SHORT-NAME>ISignal</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="308553BE-5A34-42E8-9A99-42635B541295">
      <SHORT-NAME>Signal</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="56582E97-5733-48F1-80A8-86A374FF04ED">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="7C9774D7-FCD6-4CB2-9A8F-F81770A91DC0">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="EB1A5049-1BC9-48D0-8792-2EDA7B9BFBF0">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="56B02939-E7CD-4B5C-895C-968C83A4AF04">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="152EFB5B-05C6-41FE-9599-F6A0D4173298">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="FF3ED8AC-ECE3-421B-BAB4-05BE933456E3">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="CE99486F-7C96-4179-84A3-46E342A46947">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2F05C1C5-FA84-4C04-84FA-30849746AEE8">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="892EA03C-D362-4DF4-A4E0-B4094784C0E5">
      <SHORT-NAME>DataType</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="81A7658D-CF3C-4B27-A3F6-058B6F6F978C">
          <SHORT-NAME>Constraint</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6F85217D-0F0F-407B-8FF3-32E0E5BC96C5">
          <SHORT-NAME>Semantics</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B1295819-8DAF-4741-84E0-5528E40E1282">
          <SHORT-NAME>Unit</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3DAC10CB-2D70-4259-B83F-C325956EFD47">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="3173A6C4-3D60-410D-9CEA-19651F2E6C3A">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="880A0B14-D45E-4DD7-95C6-EF6765759234">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3D840E6E-17ED-42E6-B0A2-43FE70A652F4">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="58F83ECE-016C-4934-85BE-885DF42D48DA">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="54D8FC00-354D-42E3-9AAB-2F2A11A6DD9E">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1DC462E2-31B9-41A5-B530-61D00441EC61">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="35FBC8F5-AFCF-40EB-A8C0-2B7E2DE8289B">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E090E4C2-410E-4226-963F-C1F19C752230">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="5316786D-8ED6-451A-9CDB-75EE874CF35B">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1F8CC85C-596B-4733-860D-599F74CDC693">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C0ADDC49-2C9F-43B5-A496-F7860460640E">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4C7EA234-8586-46C9-86D0-B8A9B51FA48B">
      <SHORT-NAME>SwAddrMethods</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B6916AB5-D183-44D5-B3D0-19D531E21F4F">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="353B9BB6-FB54-4EBD-988C-25CDF57CA80F">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="563BA067-5D53-4255-BB89-8652BBC0D542">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C214C664-9244-40BD-B914-E56980E90DE2">
      <SHORT-NAME>Diagnostics</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="8F318527-8150-4630-AEDE-3DB2F686EB57">
      <SHORT-NAME>Gateway</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EB771AEE-E52E-408E-9C3D-8328582A2576">
      <SHORT-NAME>LinFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="33E05B2C-545E-4F81-AB63-69B9671EC8B2">
      <SHORT-NAME>FlexrayFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="636C377B-2AF5-4FD5-8637-E72DE6C46600">
      <SHORT-NAME>DataTransformations</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B46FCE62-0735-49AF-A693-E4827AF92246">
      <SHORT-NAME>SWC</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3BCEB42E-8136-4123-ADEC-C24B5D0978D3">
      <SHORT-NAME>Constant</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>